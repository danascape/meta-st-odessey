FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-stm32mp135d-odyssey-new-board.patch \
    "
